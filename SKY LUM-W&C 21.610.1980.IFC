Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SKY LUM-W&C 21.610.1980.IFC
Time: 2023-11-03T09:57:28
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SKY LUM-W&C 21.610.1980
In: Default Storey
SolidWorks Custom Properties - Description: PWR(21W);LUM.FLUX(1980lm)
PSet_Mass_Property - Mass Measure: 0.830234; Area Measure: 0.253063 m2; Volume Measure: 0.000830234 m3
